DESCRIPTION = "${@oe.utils.read_file('${THISDIR}/${BPN}-description.md.jinja')}"

SIMPLESWITCH_PICTURE = "file://recipes-core/images/_pictures/simpleswitch-hello-world-shell.jpg"
SIMPLESWITCH_CATEGORIES = "shell demo terminal"
