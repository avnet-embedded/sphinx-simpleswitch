DESCRIPTION = "${@oe.utils.read_file('${THISDIR}/not-existing-description.md.jinja')}"
SUMMARY = "This is the summary fallback of description"

SIMPLESWITCH_PICTURE = "file://recipes-core/images/_pictures/simpleswitch-hello-world-shell.jpg"
SIMPLESWITCH_CATEGORIES = "shell demo terminal"
