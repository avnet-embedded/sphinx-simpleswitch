DESCRIPTION = "\
    A SimpleSwitch package running a hello-world from a shell script.\n \
    This also showcases the ability to store persistent data\n \
    in the $HOME directory. \
"

SIMPLESWITCH_PICTURE = "file://recipes-core/images/_pictures/simpleswitch-hello-world-shell.jpg"
SIMPLESWITCH_CATEGORIES = "shell demo terminal"
