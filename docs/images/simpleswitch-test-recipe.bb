SUMMARY = "SimpleSwitch tiny testing container"
DESCRIPTION = "SimpleSwitch tiny testing package"

inherit simpleswitch-package

SIMPLESWITCH_CATEGORIES = "test"
